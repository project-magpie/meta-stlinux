LTTNGUST_sh4 = ""

FILESEXTRAPATHS := "${THISDIR}/gdb"
SRC_URI += "file://renesas-sh-native-support.patch \
"
