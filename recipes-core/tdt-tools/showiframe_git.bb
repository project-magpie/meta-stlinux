require tdt-tools.inc

DESCRIPTION = "A tool for showing an mpeg2/4 iframe on a linuxtv video device"

RCONFLICTS_{PN} = "showiframe"
RREPLACES_{PN} = "showiframe"

