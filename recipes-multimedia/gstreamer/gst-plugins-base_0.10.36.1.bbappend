PRINC = "1"
require sh4-enable.inc
