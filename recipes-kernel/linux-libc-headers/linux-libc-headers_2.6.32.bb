require linux-libc-headers.inc 

PR = "r3"

SRC_URI += "file://linuxdvb.patch"
