ESCRIPTION = "Additional plugins for Enigma2"
PRINC = "1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/${MACHINE}"


