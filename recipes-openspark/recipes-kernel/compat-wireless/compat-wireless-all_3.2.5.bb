include compat-wireless.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "19670520d7f0289a5b4c6fb28520b2ac"
SRC_URI[sha256sum] = "a7bc714c8e438dea348a154c6f4ca583cdbc5155467ec9ae8498a90c70f89658"
