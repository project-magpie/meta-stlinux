SRC_URI_spark="git://github.com/DvbMedia/branding-module.git;protocol=git;branch=oea-1.0"

SRC_URI_spark7162="git://github.com/DvbMedia/branding-module.git;protocol=git;branch=oea-1.0"

