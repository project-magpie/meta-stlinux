require tdt-tools.inc

RDEPEND += "stslave-fw"

DESCRIPTION = "A tool for uploading the firmware to the slave DSPs"

