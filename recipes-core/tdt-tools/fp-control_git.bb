require tdt-tools.inc

DESCRIPTION = "A tool for uploading the firmware to the slave DSPs"

