FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/${DISTRO}"

