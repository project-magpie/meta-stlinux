DESCRIPTION = "gstreamer libxtrend plugin"
LICENSE = "CLOSED"
SECTION = "multimedia"
PRIORITY = "optional"

do_install_spark() {
# we don't have a libxtrend plugin for sh4, thu we override the install of the mipsel lib
#
}

do_install_spark7162() {
# we don't have a libxtrend plugin for sh4, thu we override the install of the mipsel lib
#
}

