STLINUX_FW_BOARD = "STx7111"

require stlinux24-sh4-fw-fdma.inc 

PR = "r4"
