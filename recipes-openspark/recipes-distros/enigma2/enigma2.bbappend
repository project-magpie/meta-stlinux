PRINC = "61"

DEPENDS_spark += " \
	tdt-driver \
        libmmeimage \
	"

DEPENDS_spark7162 += " \
        tdt-driver \
        libmmeimage \
        "

