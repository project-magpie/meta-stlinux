FILESEXTRAPATHS := "${THISDIR}/files"
PRINC := "${@int(PRINC) + 5}"

#SRC_URI += "file://gcc-4.6.3-stm-120618.patch"
