require tdt-driver.inc
SUMMARY = "Driver modules from TDT"
DESCRIPTION = "Driver modules from TDT"

MAINTAINER = "Christian Ege (graugans) <ka@gmail.com>"

PR = "r21"


